# Keil uVision project Z8D16R_2.uvproj, settings and files
target Z8D16R-2 (MCS-51)
  device: 8052 (all Variants) Generic
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: Z8D16R_2 +hex
  AfterMake: .\Tool\gen_bin.bat
  c flags: Optimize=8 SizeSpeed=1
  c define: _DEV_BOARD_,_FPGA_DEMO_EN_
  c include: .\SrcFile\StartUp\CPU;.\SrcFile\Frame\Inc;.\SrcFile\Func\Inc;.\SrcFile\Lib;.\SrcFile\App\Inc
  group Startup
    ./SrcFile/StartUp/: Z8_STARTUP.A51 Main.c
    ./SrcFile/StartUp/CPU/: HardApiAsm.a51
  group Func
    ./SrcFile/Func/: TbcFunc.c OtpFunc.c LcdFunc.c AdcFunc.c ScuFunc.c UartFunc.c TimerFunc.c WdtFunc.c Hmac.c Sha1.c Uc8118.c NFCFunc.c
  group Frame
    ./SrcFile/Frame/: IsrFrame.c OtpFrame.c AdcFrame.c SM4Process.c UartFrame.c
  group Lib
    ./SrcFile/Lib/: PUTCHAR.c Debug.c Crc.c Z8D16R_SM4_L_V1.0.LIB BigApiAsm.a51
  group Doc
    ./SrcFile/Doc/: Z8D16R-2 OTP DEMO使用说明.txt
